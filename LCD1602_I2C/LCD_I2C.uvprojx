# Keil uVision project LCD_I2C.uvprojx, settings and files
target STM32F103C8T6 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD_I2C +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./: systick_time.c systick_time.h gpio.c gpio.h i2c.c i2c.h lcd_1602.c lcd_1602.h PCF8574.c PCF8574.h main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
